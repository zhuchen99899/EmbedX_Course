# Keil uVision project template.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: template +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xE
  c include: ..\..\platform\mcu\stm32f103ze\core\include;..\..\platform\mcu\stm32f103ze\libraries\CMSIS\Core\Include;..\..\platform\mcu\stm32f103ze\libraries\STM32F1xx_HAL_Driver\Inc;..\..\platform\mcu\stm32f103ze\libraries\CMSIS\Device\ST\STM32F1xx\Include;..\..\platform\mcu\stm32f103ze\bsp\it;..\..\platform\mcu\stm32f103ze\bsp\sys;..\..\platform\mcu\stm32f103ze\bsp\delay
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group app
    ../../app/: main.c
  group core
    ../../platform/mcu/stm32f103ze/core/ARM/: startup_stm32f103xe.s
    ../../platform/mcu/stm32f103ze/core/: system_stm32f1xx.c
    ../../platform/mcu/stm32f103ze/libraries/CMSIS/Core/Include/: cmsis_armcc.h core_cm3.h
  group ST_HAL
    ../../platform/mcu/stm32f103ze/libraries/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_cortex.c stm32f1xx_hal_dma.c stm32f1xx_hal_exti.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c
  group bsp
    ../../platform/mcu/stm32f103ze/bsp/it/: stm32f1xx_it.c
    ../../platform/mcu/stm32f103ze/bsp/sys/: sys.c
    ../../platform/mcu/stm32f103ze/bsp/delay/: delay.c
